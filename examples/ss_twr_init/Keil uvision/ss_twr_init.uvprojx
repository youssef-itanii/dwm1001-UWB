# Keil uVision project ss_twr_init.uvprojx, settings and files
target nrf52832_xxaa (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BOARD_DW1001_DEV BSP_SIMPLE  CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 SWI_DISABLE0
  c misc: --reduce_paths
  c include: ..\response_queue;..\UART;..\config;..\..\..\nRF5_SDK_14.2.0\components;..\..\..\nRF5_SDK_14.2.0\components\boards;..\..\..\nRF5_SDK_14.2.0\components\drivers_nrf\clock;..\..\..\nRF5_SDK_14.2.0\components\drivers_nrf\common;..\..\..\nRF5_SDK_14.2.0\components\drivers_nrf\delay;..\..\..\nRF5_SDK_14.2.0\components\drivers_nrf\gpiote;..\..\..\nRF5_SDK_14.2.0\components\drivers_nrf\hal;..\..\..\nRF5_SDK_14.2.0\components\drivers_nrf\nrf_soc_nosd;..\..\..\nRF5_SDK_14.2.0\components\drivers_nrf\spi_master;..\..\..\nRF5_SDK_14.2.0\components\drivers_nrf\uart;..\..\..\nRF5_SDK_14.2.0\components\libraries\atomic;..\..\..\nRF5_SDK_14.2.0\components\libraries\balloc;..\..\..\nRF5_SDK_14.2.0\components\libraries\bsp;..\..\..\nRF5_SDK_14.2.0\components\libraries\button;..\..\..\nRF5_SDK_14.2.0\components\libraries\fifo;..\..\..\nRF5_SDK_14.2.0\components\libraries\experimental_log;..\..\..\nRF5_SDK_14.2.0\components\libraries\experimental_log\src;..\..\..\nRF5_SDK_14.2.0\components\libraries\experimental_memobj;..\..\..\nRF5_SDK_14.2.0\components\libraries\experimental_section_vars;..\..\..\nRF5_SDK_14.2.0\components\libraries\scheduler;..\..\..\nRF5_SDK_14.2.0\components\libraries\strerror;..\..\..\nRF5_SDK_14.2.0\components\libraries\timer;..\..\..\nRF5_SDK_14.2.0\components\libraries\util;..\..\..\nRF5_SDK_14.2.0\components\libraries\uart;..\..\..\nRF5_SDK_14.2.0\components\toolchain;..\..\..\deca_driver;..\..\..\deca_driver\port;..\..\..\nRF5_SDK_14.2.0\external\fprintf;..\..\..\nRF5_SDK_14.2.0\external\segger_rtt;..\..\..\nRF5_SDK_14.2.0\external\freertos\;..\..\..\nRF5_SDK_14.2.0\external\freertos\source;..\..\..\nRF5_SDK_14.2.0\external\freertos\config;..\..\..\nRF5_SDK_14.2.0\external\freertos\source\include;..\..\..\nRF5_SDK_14.2.0\external\freertos\portable\ARM\nrf52;..\..\..\nRF5_SDK_14.2.0\external\freertos\portable\CMSIS\nrf52;..\..\..\nRF5_SDK_14.2.0\external\freertos\source\portable;..\..\..\boards;..\..\..
  asm define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DSWI_DISABLE0
  asm include: ..\..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\toolchain;..\..\..\..;..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\external\segger_rtt;..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ../: main.c ss_init_main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../nRF5_SDK_14.2.0/components/boards/: boards.c
  group Board Support
    ../../../nRF5_SDK_14.2.0/components/libraries/bsp/: bsp.c bsp_nfc.c
  group nRF_Drivers
    ../../../nRF5_SDK_14.2.0/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../nRF5_SDK_14.2.0/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../nRF5_SDK_14.2.0/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../nRF5_SDK_14.2.0/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../nRF5_SDK_14.2.0/components/drivers_nrf/clock/: nrf_drv_clock.c
  group nRF_Libraries
    ../../../nRF5_SDK_14.2.0/components/libraries/button/: app_button.c
    ../../../nRF5_SDK_14.2.0/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../nRF5_SDK_14.2.0/components/libraries/scheduler/: app_scheduler.c
    ../../../nRF5_SDK_14.2.0/components/libraries/balloc/: nrf_balloc.c
    ../../../nRF5_SDK_14.2.0/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../nRF5_SDK_14.2.0/components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../nRF5_SDK_14.2.0/components/libraries/strerror/: nrf_strerror.c
    ../../../nRF5_SDK_14.2.0/components/libraries/fifo/: app_fifo.c
    ../../../nRF5_SDK_14.2.0/components/libraries/uart/: app_uart_fifo.c retarget.c
  group nRF_Log
    ../../../nRF5_SDK_14.2.0/components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../nRF5_SDK_14.2.0/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group Decadriver
    ../../../deca_driver/: deca_device.c deca_params_init.c
    ../../../deca_driver/port/: port_platform.c
  group Freertos
    ../../../nRF5_SDK_14.2.0/external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../nRF5_SDK_14.2.0/external/freertos/source/portable/MemMang/: heap_1.c
    ../../../nRF5_SDK_14.2.0/external/freertos/portable/ARM/nrf52/: port.c
    ../../../nRF5_SDK_14.2.0/components/libraries/timer/: app_timer_freertos.c
    ../../../nRF5_SDK_14.2.0/external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c portmacro_cmsis.h
  group Config
    ../../../nRF5_SDK_14.2.0/external/freertos/config/: FreeRTOSConfig.h
  group Uart
    ../UART/: UART.c
  group response_queue
    ../response_queue/: response_queue.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
